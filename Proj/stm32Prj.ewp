# IAR project stm32Prj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ..\stmLIB\Inc; ..\stmLIB\STM32F1xx\Include; ..\freeRTOS\include; ..\freeRTOS\portable\IAR\ARM_CM3; ..\userSRC
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\userSRC
  OBJCOPY.OOCOutputFile: stm32Prj.srec
  ILINK.IlinkOutputFile: stm32Prj.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group freeRTOS
    ../freeRTOS/: list.c queue.c tasks.c
  group freeRTOS/portable
    ../freeRTOS/portable/MemMang/: heap_4.c
    ../freeRTOS/portable/IAR/ARM_CM3/: port.c portasm.s
  group startup/asm
    ../stmLIB/STM32F1xx/Source/iar/: startup_stm32f103xe.s
  group startup/cmsis
    ../stmLIB/STM32F1xx/Source/: system_stm32f1xx.c
  group stmLIB/inc
    ../stmLIB/Inc/: stm32f1xx_hal.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_uart.h stm32f1xx_hal_usart.h
  group stmLIB/src
    ../stmLIB/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
  group userSRC
    ../userSRC/: FreeRTOSConfig.h main.c
  group userSRC/interrupt
    ../userSRC/interrupt/: stm32f1xx_it.c stm32f1xx_it.h
